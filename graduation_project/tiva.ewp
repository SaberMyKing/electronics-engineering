# IAR project tiva.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCIncludePath2: D:\TI-M4 Files\Tiva C Series API; D:\TI-M4 Files\my_project\new; D:\TI-M4 Files\my_project\new\My lib; D:\TI-M4 Files\Tiva C Series API\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\TI-M4 Files\Tiva C Series API
  OBJCOPY.OOCOutputFile: tiva.srec
  ILINK.IlinkOutputFile: tiva.out
  ILINK.IlinkAdditionalLibs: D:\TI-M4 Files\Tiva C Series API\driverlib\ewarm\Exe\driverlib.a; D:\TI-M4 Files\Tiva C Series API\sensorlib\ewarm\Exe\sensorlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group API/driverlib
    ../../Tiva C Series API/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c Timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group include
    include/: buttons.c buttons.h rgb.c rgb.h
  group main
    ./: main.c startup_ewarm.c
  group My lib
    My lib/: clock.c clock.h common.h IIC.c IIC.h mpr121.c mpr121.h mpu6050.c mpu6050.h my_eeprom.c my_eeprom.h OLED.c OLED.h pedometer.c pedometer.h Timers.c Timers.h touch_led_bee.c touch_led_bee.h uart_PC.c uart_PC.h uart_send.c uart_send.h WIFI.c WIFI.h
